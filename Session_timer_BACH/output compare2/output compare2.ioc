# file: output compare2.ioc
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Mcu.Family=STM32F1
Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=STM32CubeIDE
RCC.AHBCLKDivider=RCC_SYSCLK_DIV2
RCC.AHBFreq_Value=8000000
RCC.APB1CLKDivider=RCC_HCLK_DIV2
RCC.APB1Freq_Value=4000000
RCC.APB1TimFreq_Value=8000000
RCC.APB2Freq_Value=8000000
RCC.APB2TimFreq_Value=8000000
RCC.HCLKFreq_Value=8000000
RCC.PLLSourceVirtual=RCC_PLLSOURCE_HSE
RCC.SYSCLKFreq_VALUE=16000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
RCC.USBFreq_Value=16000000
board=custom

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2026 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
#include "main.h"
#include "lbr.h"

/* USER CODE BEGIN PTD */
uint32_t cnt = 0;

/* USER CODE END PTD */

/* USER CODE BEGIN PM */
void TIM3_ISR(void){
	TIM3->DIER &= ~(0X01<<0);
	NVIC->ISER[0] |= (0x01<<28);
	if(!(TIM3->SR & 0x01)){
		TIM3->SR &= ~(0X01<<0);
		cnt++;
	}
}
 void delay(uint16_t time){
	 uint16_t current_cnt = cnt;
	 while((cnt-current_cnt) < time );
 }

/* USER CODE END PM */

void SystemClock_Config(void);
static void MX_GPIO_Init(void);

int main(void)
{

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

  /* Initialize all configured peripherals */
  MX_GPIO_Init();
  /* USER CODE BEGIN 2 */

  GPIO_init(GPIOA, PIN_0, OUTPUT_MODE_10MHZ, AL_FUNC_PUSH_PULL, NO_PULL );
  GPIO_init(GPIOA, PIN_1, OUTPUT_MODE_10MHZ, AL_FUNC_PUSH_PULL, NO_PULL );
  GPIO_init(GPIOB, PIN_10, OUTPUT_MODE_10MHZ, AL_FUNC_PUSH_PULL, NO_PULL );
  GPIO_init(GPIOB, PIN_11, OUTPUT_MODE_10MHZ, AL_FUNC_PUSH_PULL, NO_PULL );
  TIM2_PWM_Init(CH1);
  TIM2_PWM_Init(CH2);

  uint16_t v1 = 1000, v2 = 0;
  uint32_t  step = 1;
  uint8_t  phase = 0;

  /* USER CODE END 2 */

  /* Infinite loop */
  while (1)
  {

    /* USER CODE BEGIN 3 */

	    switch (phase) {
	        case 0:
	            if(v1 >= step){
	            	v1 -= step;
	            	if(v1 <= step){
	            		v1=0;
	            		v2=1000;
	            		phase = 1;
	            	}
	            }

	            TIM2_PWM_SetDuty(CH1, v1);
	            TIM2_PWM_SetDuty(CH2, v2);
	            break;

	        case 1:
	            if(v2 >= step){
	            	v2 -= step;
	            	if(v2 < step){
	            		v2=0;
	            		v1=1000;
	            		phase = 0;
	            	}
	            }
	            TIM2_PWM_SetDuty(CH1, v1);
	            TIM2_PWM_SetDuty(CH2, v2);
	            break;
	    }

	    	HAL_Delay(10);

  }

  /* USER CODE END 3 */
}

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  /** Initializes the RCC Oscillators according to the specified parameters
  * in the RCC_OscInitTypeDef structure.
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSI;
  RCC_OscInitStruct.HSIState = RCC_HSI_ON;
  RCC_OscInitStruct.HSICalibrationValue = RCC_HSICALIBRATION_DEFAULT;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_NONE;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_HSI;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV1;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_0) != HAL_OK)
  {
    Error_Handler();
  }
}

static void MX_GPIO_Init(void)
{

  /* GPIO Ports Clock Enable */
  __HAL_RCC_GPIOD_CLK_ENABLE();
  __HAL_RCC_GPIOA_CLK_ENABLE();

}

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}
